# Keil uVision project 5.1_new_sgt.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC848 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: 5-1_new_sgt +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: Main_bkcd.c Setup_ADC.c setup_bkcd.c define_stuct.h main.h R_MAIN.H task3_bkcd.c START_AD.A51 Опис_Таб_Кан.h TAB_NO_LINE_3.h TAB_NO_LINE_1.H TAB_NO_LINE_2.h assemb.c
  group read me
    ./: readme.txt
